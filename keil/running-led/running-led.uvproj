# Keil uVision project running-led.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MDR32F9Q2I Milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: running-led +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_MDR32F9x.s main.c system_MDR32F9Qx.c
